# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Delay.h infrared.c infrared.h int0.c int0.h LCD1602.c LCD1602.h main.c timer0.c timer0.h pwm.c pwm.h timer1.c timer1.h
